FILESEXTRAPATHS:prepend := "${THISDIR}/ar0144:"


SRC_URI += "file://0001-isp-vvcam-add-ar0144.patch"  


