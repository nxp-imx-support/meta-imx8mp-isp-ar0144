FILESEXTRAPATHS:prepend := "${THISDIR}/ar0144:"
  
SRC_URI += "file://0001-linux-kernel-add-new-ar0144-dtb.patch"
